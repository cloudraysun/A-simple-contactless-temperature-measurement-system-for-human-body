# Keil uVision project project2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\timer;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\MLX90614;..\HARDWARE\distence
  asm include: ..\CORE;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\HARDWARE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c main.h stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c LED.h
    ../HARDWARE/LCD/: lcd_init.c lcd_init.h lcd.c lcd.h lcdfont.h
    ../HARDWARE/MLX90614/: MLX90614.C MLX90614.H
    ../HARDWARE/distence/: SR04.c SR04.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/timer/: timer.c timer.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/sys/: sys.c sys.h
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c
